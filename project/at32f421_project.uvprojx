# Keil uVision project at32f421_project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F421C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: at32f421_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,AT_START_F421_V1_0
  c include: ..\source_code\app;..\source_code\app\control;..\source_code\app\filter;..\source_code\app\pid;..\source_code\app\quaternion;..\source_code\common;..\source_code\dev\bmp280;..\source_code\dev\mpu6050;..\source_code\dev\spl06;..\source_code\freeRTOS;..\source_code\freeRTOS\include;..\source_code\freeRTOS\RVDS;..\source_code\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\source_code\Libraries\CMSIS\CM4\CoreSupport;..\source_code\Libraries\CMSIS\CM4\DeviceSupport;..\source_code\user\inc;..\source_code\hal\simulation_i2c;..\source_code\hal\i2c;..\source_code\hardware\gpio;..\source_code\hardware\rcc;..\source_code\hardware\usart;..\source_code\hal\usart;..\source_code\hardware\dma;..\source_code\common\circular_queue;..\source_code\protocol_stack\ibus;..\source_code\app\remote_task;..\source_code\dal\remote;..\source_code\hardware\timer;..\source_code\hal\pwm;..\source_code\dev\motor
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ../../caijiflight_v0.3/Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f421c8t7.s
  group CMSIS
    ../../caijiflight_v0.3/Libraries/CMSIS/CM4/DeviceSupport/: system_at32f4xx.c
  group lib
    ../../caijiflight_v0.3/Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
  group user
    ../source_code/user/src/: led.c my_systick.c tim_input_capture.c time.c uart.c
  group freeRTOS
    ../../caijiflight_v0.3/freeRTOS/: list.c queue.c tasks.c
    ../../caijiflight_v0.3/freeRTOS/MemMang/: heap_4.c
    ../../caijiflight_v0.3/freeRTOS/RVDS/: port.c
    ../source_code/freeRTOS/: FreeRTOSConfig.h
  group app
    ../source_code/app/: main.c at32f4xx_it.c
    ../source_code/app/filter/: filter.c
    ../source_code/app/pid/: pid.c
    ../source_code/app/quaternion/: quaternion.c
    ../source_code/app/control/: control.c
    ../source_code/app/remote_task/: remote_task.c
  group hardware
    ../source_code/hardware/gpio/: gpio_config.c
    ../source_code/hardware/rcc/: rcc_config.c
    ../source_code/hardware/usart/: usart_config.c
    ../source_code/hardware/dma/: dma_config.c
    ../source_code/hardware/timer/: timer_config.c
  group hal
    ../source_code/hal/i2c/: i2c_hal.c i2c_hal_config.c
    ../source_code/hal/simulation_i2c/: simulation_i2c.c simulation_i2c_config.c
    ../source_code/hal/usart/: usart_hal.c usart_hal_config.c
    ../source_code/hal/pwm/: pwm_hal.c pwm_hal_config.c
  group dev
    ../source_code/dev/mpu6050/: mpu6050.c mpu6050_config.c
    ../source_code/dev/motor/: motor.c motor_config.c
  group common
    ../source_code/common/: common.c
    ../source_code/common/circular_queue/: circular_queue.c
  group protocol_stack
    ../source_code/protocol_stack/ibus/: ibus.c
  group dal
    ../source_code/dal/remote/: remote_data.c
